require linux-mainline.inc

DESCRIPTION = "Mainline Latest Linux kernel"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = ""

SRC_URI[sha256sum] = "a9214b97085af98dfcaaa8c2e8eff4858c1d53dccd6c58931cf7b0455ff9bf87"

SRC_URI[sunxi-patches.sha256sum] = "77bb77d246933ac9bcc78e86552ce0a14ed1d05a5bf16b4657449224ca566175"
